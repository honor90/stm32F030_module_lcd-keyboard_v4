# Keil uVision project module_lcd&keyboard.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: module_lcd&keyboard
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source\Templates;.\User\src;.\User\inc;.\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Driver\src;.\STM32F0xx_StdPeriph_Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./: startup_stm32f030.s
  group main
    ./User/src/: main.c usart.c hd44780_driver.c LCD.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group stdperiph
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
    ./STM32F0xx_StdPeriph_Driver/: stm32f0xx_conf.h
  group DOC
    ./: Описание команд.txt
